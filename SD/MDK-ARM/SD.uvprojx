# Keil uVision project SD.uvprojx, settings and files
target FLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Core;..\User;..\System\sys;..\System\delay;..\System\usart;..\Hardware\LED;..\Software\SPI;..\Hardware\SD;..\STM32F10x_FWLib\inc;..\Malloc;..\Hardware\OLED;..\System\usart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Core/Startup/: startup_stm32f10x_md.s
  group CORE
    ../Core/: core_cm3.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_rcc.c stm32f10x_usart.c
  group SYSTEM
    ../System/sys/: sys.c
    ../System/delay/: delay.c
    ../System/usart/: usart.c
  group USER
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../Hardware/LED/: led.c
    ../Hardware/SD/: MMC_SD.C MMC_SD_User.c
    ../Hardware/OLED/: screen.c oled.c
  group SOFTWARE
    ../Software/SPI/: spi.c
  group MALLOC
    ../Malloc/: malloc.c
