# Keil uVision project 0.96OLED-SPI.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 0.96OLED-SPI +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Core;..\FWLIB\inc;..\Hardware\LED;..\Hardware\OLED;..\System\delay;..\System\SYS;..\User;..\Software\spi;..\System\RTC;..\CMSIS\DAP\Include;..\CMSIS-DSP-Tools;..\CMSIS\DAP\Config;..\Software\iic
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Core/Startup/: startup_stm32f10x_md.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_rtc.c
  group CORE
    ../Core/: core_cm3.c
  group SYSTME
    ../System/SYS/: sys.c
    ../System/delay/: delay.c
  group HARDWARE
    ../Hardware/LED/: led.c
    ../Hardware/OLED/: oled.c screen.c
  group SOFTWARE
    ../Software/spi/: spi.c
    ../Software/iic/: iic.c
  group USER
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
